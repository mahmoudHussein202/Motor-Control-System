# Keil uVision project ECU1_TEST.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECU1_TEST
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -std=c11
  c include: C:\ti\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group OS
    ./OS/: OS.c OS.h OS_backend.c
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
  group CAN
    ./CAN/: Can.c Can.h
  group UART
    ./UART/: uart_config.c uart_config.h
  group SYSCLK
    ./SYSCLK/: sysclk.c sysclk.h
  group SYSTICK
    ./SYSTICK/: systick.c systick.h
  group RGB
    ./RGB/: RGB.c RGB.h ttttm4c123gh6pm.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
