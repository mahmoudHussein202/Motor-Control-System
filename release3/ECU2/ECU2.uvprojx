# Keil uVision project ECU2.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECU2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c misc: -std=c11
  c include: C:\ti\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./APP/: APP.c
  group OS
    ./OS/: OS.c OS.h
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
  group SERVICES
    ./SERVICES/ADC/: adc.c adc.h adc_config.h
    ./SERVICES/CAN/: Can.c Can.h Can_Config.h
  group HAL
    ./HAL/: Button.c Button.h led.c Led.h
  group MCAL
    ./MCAL/: Common_Macros.h Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h MCAL.h Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h StandardTypes.h tm4c123gh6pm_registers.h SYSTICK_DRIV.c SYSTICK_DRIV.h SYSTICK_cfg.h SYSTICK_PBcfg.c SYSTICK_reg.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
