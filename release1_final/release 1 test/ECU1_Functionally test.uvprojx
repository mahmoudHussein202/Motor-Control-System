# Keil uVision project ECU1_Functionally test.uvprojx, settings and files
target ECU1_Test (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECU1_Functionally test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -std=c11
  c include: C:\ti\TivaWare_C_Series-2.1.4.178;.\uart;.\timer;.\systick;.\sysclk;.\can;C:\ti\TivaWare_C_Series-2.1.4.178\inc;.\inc;C:\ti\tivaware_c_series_2_1_4_178
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Src
    ./Src/: main.c test.c test.h
  group uart
    ./uart/: uart_config.c uart_config.h
  group systick
    ./systick/: systick.c systick.h
  group sysclk
    ./sysclk/: sysclk.c sysclk.h
  group can
    ./can/: CAN.h CAN.c
  group Library
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
